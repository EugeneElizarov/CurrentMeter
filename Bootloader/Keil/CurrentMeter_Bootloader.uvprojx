# Keil uVision project CurrentMeter_Bootloader.uvprojx, settings and files
target CurrentMeter_Bootloader (6220000::V6.22::ARMCLANG)
  device: STM32F303CBTx STMicroelectronics
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M4") FPU3(SP) CLOCK(12000000) ELITTLE
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F303xC
  c include: ..\..\CMSIS\Core\Include;..\..\CMSIS\Device\ST\STM32F3xx\Include;..\src;..\BSP;..\..\TinyUSB\src
  asm define: STM32F303xC
  asm include: as above
  scatter file: ..\src\bootloader.sct
  group CMSIS
    ../../CMSIS/Device/ST/STM32F3xx/Source/Templates/ARM/: startup_stm32f303xc.s
    ../../CMSIS/Device/ST/STM32F3xx/Source/: system_stm32f3xx.c
  group Bootloader
    ../src/: main.c boot_crc32.c usb_descriptors.c
  group BSP
    ../BSP/: bsp_aes.c bsp_flash.c bsp_fat12.c bsp_gpio.c bsp_led.c bsp_rcc.c bsp_settings.c bsp_usb_msc.c
  group TinyUSB
    ../../TinyUSB/src/: tusb.c
    ../../TinyUSB/src/common/: tusb_fifo.c
    ../../TinyUSB/src/device/: usbd.c usbd_control.c
    ../../TinyUSB/src/class/msc/: msc_device.c
    ../../TinyUSB/src/portable/st/stm32_fsdev/: dcd_stm32_fsdev.c fsdev_common.c
